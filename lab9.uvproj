# Keil uVision project lab9.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: lab9
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Lab9;..\STM32F\includes
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f30x.s cli.c main.c stm32f3_Button.c stm32f3_DMA.c stm32f3_Exec.c stm32f3_Flash.c stm32f3_GeneralTimer2.c stm32f3_LEDS.c stm32f3_Tools.c stm32f3_UART.c stm32f3_Watchdog.c stm32f3_discovery_board.c
    ../STM32F/src/: system_stm32f30x.c stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_rcc.c stm32f30x_syscfg.c stm32f3_discovery_lsm303dlhc.c
